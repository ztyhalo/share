# Keil uVision project eFramework.uvproj, settings and files
target eFramework (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: eFramework +hex
  c flags: Optim=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: .\Libraries\CMSIS\CM3\CoreSupport;.\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;.\Libraries\STM32F10x_StdPeriph_Driver\inc;.\Libraries\STM32_USB-FS-Device_Driver\inc;.\source;.\source\Application;.\source\Board;.\source\uCOS-II\Port;.\source\uCOS-II\Port\Port_Cpu;.\source\uCOS-II\Source;.\source\APP1\APP_USBMouse\inc
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group startup
    ./Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ./Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    ./Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
  group library
    ./Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group board
    ./source/Board/: stm32f10x_it.c board_cfg.h board_cfg.c
  group application
    ./source/uCOS-II/Port/Port_Cpu/: app_cfg.h
    ./source/Application/: app_cfg.c main.c usart.c can.c
  group uCOSII
    ./source/uCOS-II/Port/Port_Cpu/: OS_CPU_A.ASM OS_CPU_C.C
    ./source/uCOS-II/Port/: os_cfg.h
    ./source/uCOS-II/Source/: ucos_ii.c
